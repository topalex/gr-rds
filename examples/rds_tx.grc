options:
  parameters:
    category: RDS
    generate_options: qt_gui
    id: rds_tx
    output_language: python
  states: {}

blocks:
- name: fm_max_dev
  id: variable
  parameters:
    value: 80e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 87.5e6
  states: {}
- name: input_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '10'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.3'
  states: {}
- name: input_gain
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pilot_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '3'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.09'
  states: {}
- name: pilot_gain
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: ps
  id: variable_text_box
  parameters:
    converver: str_converter
    formatter: None
    label: PS
    value: '"WDR 3"'
  states: {}
- name: rds_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '3'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.27'
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: stereo_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '3'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.3'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 19e3*20
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: input_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rds_gain
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pilot_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: input_gain
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '160'
    type: float
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: gr_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    maxoutbuf: outbuffer
    num_inputs: '4'
    type: float
  states: {}
- name: gr_char_to_float_0
  id: blocks_char_to_float
  parameters:
    maxoutbuf: outbuffer
    scale: '1'
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: gr_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 38e3
    offset: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 57e3
    offset: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 19e3
    offset: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
    maxoutbuf: outbuffer
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5e3
    gain: '1'
    interp: '1'
    maxoutbuf: outbuffer
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: .5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '30'
    sample_rate: 1e6
    sync: ''
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '380000'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '38'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 89.8e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: WDR 3
    pty: '14'
    pty_locale: '0'
    radiotext: GNU Radio <3
    ta: 'False'
    tp: 'True'
  states: {}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: 1e6
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', gr_add_xx_1, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', gr_add_xx_1, '1']
- [blocks_multiply_const_vxx_0_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [blocks_socket_pdu_0, pdus, rds_encoder_0, rds in]
- [gr_add_xx_0, '0', low_pass_filter_0_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [gr_char_to_float_0, '0', blocks_repeat_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', rational_resampler_xxx_1, '0']
- [gr_map_bb_0, '0', gr_char_to_float_0, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [gr_multiply_xx_1, '0', gr_add_xx_1, '2']
- [gr_sig_source_x_0, '0', gr_multiply_xx_1, '0']
- [gr_sig_source_x_0_0, '0', gr_multiply_xx_0, '0']
- [gr_sig_source_x_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [gr_sub_xx_0, '0', low_pass_filter_0_0_0, '0']
- [gr_unpack_k_bits_bb_0, '0', gr_map_bb_0, '0']
- [low_pass_filter_0, '0', gr_multiply_xx_0, '1']
- [low_pass_filter_0_0, '0', gr_add_xx_1, '3']
- [low_pass_filter_0_0_0, '0', gr_multiply_xx_1, '1']
- [rational_resampler_xxx_0, '0', gr_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', gr_sub_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', gr_add_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', gr_sub_xx_0, '1']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink, '0']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']

metadata:
  file_format: 1
